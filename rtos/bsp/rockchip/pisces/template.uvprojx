# Keil uVision project template.uvprojx, settings and files
target rtthread-pisces (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: rtthread-pisces
  c flags: Optim=1 uC99=1 wLevel=1
  c define: RT_USING_ARM_LIBC
  c misc: --gnu --diag_suppress=188
  c include: applications;.;drivers;Libraries\hal\inc;Libraries\CMSIS\Device\Pisces\Include;Libraries\CMSIS\Core\Include;..\..\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\armlibc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\rk_hal\lib\CMSIS\Device\Pisces\Source\Templates\ARM\pisces_ac5.sct
  group applications
    ./applications/: application.c startup.c
  group drivers
    ./drivers/: board.c drv_uart.c drv_clock.c dma.c drv_audio.c drv_cache.c drv_display.c drv_dma.c drv_dsi.c drv_dsp.c drv_i2s.c drv_panel.c drv_pdm.c drv_spi.c drv_spi2apb.c drv_uncache_heap.c drv_vad.c drv_vop.c dsp.c rk_pm.c
  group rk_hal
    ./Libraries/hal/src/: hal_debug.c hal_base.c hal_uart.c hal_pl330.c
    ./rk_hal/lib/CMSIS/Device/Pisces/Source/Templates/: system_pisces.c
    ./rk_hal/lib/CMSIS/Device/Pisces/Source/Templates/ARM/: startup_pisces.s
    ./rk_hal/lib/hal/src/: hal_nvic.c hal_cru.c hal_dsi.c hal_gpio.c hal_grf.c hal_i2s.c hal_mbox.c hal_pd.c hal_pdm.c hal_pm.c hal_spi.c hal_timer.c hal_spi2apb.c hal_vad.c hal_vop.c hal_wdt.c hal_audio.c hal_pcm.c
  group kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group deviceDriver
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/pm/: pm.c
    ../../components/drivers/audio/: audio.c audio_pipe.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group test
    ./test/: audio_test.c demo_test.c display_test.c dma_test.c dsp_test.c spi_test.c spi2apb_test.c tc_comm.c tc_sample.c
